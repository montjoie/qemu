## hw/crypto/Kconfig
```kconfig
config ALLWINNER_CRYPTO_SUN4I_SS
    bool
config ALLWINNER_CRYPTO_SUN8I_CE
    bool
```
